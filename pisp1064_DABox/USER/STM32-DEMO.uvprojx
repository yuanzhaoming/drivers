# Keil uVision project STM32-DEMO.uvprojx, settings and files
target pisp1064_DABox (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pisp1064_DABox +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\kernel-include;..\kernel;..\drivers;..\components;..\DeviceDrivers;..\finsh;..\dfs;..\lwip\src;..\lwip\src\include;..\lwip\src\arch\include;..\lwip\src\include\ipv4;..\file
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s context_rvds.S cpuport.c backtrace.c div0.c showmem.c
  group USER
    ./: stm32f10x_it.c startup.c application.c echo.c spi_bus.c tcpserver.c tftp.c pcm4104.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group kernel
    ../kernel/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group kernel-include
    ../kernel-include/: rtdebug.h rtdef.h rthw.h rtm.h rtservice.h rtthread.h rtdevice.h spi.h
  group drivers
    ../drivers/: board.c led.c usart.c spi_core.c spi_dev.c spi_flash_w25qxx.c rt_stm32f10x_spi.c rt_spi_flash_device.c enc28j60.c spi_instruction.c key_input.c internal_flash.c protocol.c do_data.c inc.c dsp_reset.c address_485.c IIC_eeprom.c OLED.c timer2.c
  group components
    ../components/: components.c
  group DeviceDrivers
    ../DeviceDrivers/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c serial.c
  group finsh
    ../finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group dfs
    ../dfs/: dfs.c dfs_elm.c dfs_file.c dfs_fs.c dfs_posix.c ff.c
  group lwip
    ../lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/src/arch/: sys_arch.c
    ../lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group 说明
    ../说明/: readme.txt
  group file
    ../file/: file.c
  group atsha204a
    ../SHA204A/: sha204a_comm.c sha204a_comm_marshaling.c Sha256_atmel.c delay.c hal_i2c_sha204a.c sha204_authentication.c sha204_data.c sha204a.c
  group task
    ../task/: rs485_task.c spi_task.c
software components: CMSIS:CORE 4.3.0
